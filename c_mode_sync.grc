<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>c_mode_sync</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>868.949951e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_DL_0</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_UL</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_DL_0</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_UL</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>2</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>K:\corr.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>K:\out.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>[0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, 0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, -0 - 1j, 0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, -0 - 1j, 0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, -0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, -0 - 1j, 0 - 1j, -0 - 1j, 0 - 1j, 0 - 1j, 0 - 1j, -0 - 1j, 0 - 1j, 0 + 1j, 0 + 1j, 0 + 1j, 0 + 1j, -0 + 1j, 0 + 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, -0 + 1j, 0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 - 1j, 0 - 1j, 0 - 1j, 0 - 1j, -0 - 1j, 0 - 1j, 0 + 1j, 0 + 1j, 0 + 1j, 0 + 1j, -0 + 1j, 0 + 1j, 0 + 1j, -0 + 1j, 0 - 1j, -0 - 1j, 0 + 1j]</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_UL</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_UL</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.4</value></param>
<param><key>ymax</key><value>200</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(audio_rate * audio_interp)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate_UL</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_UL</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_UL</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
